File: pcb/feb42.kicad_sch (KiCad schematic)
At the start: 302 parts

Commit message: prod
Parts:
- added KEY1: BSP, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY10: W, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY11: Q, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY12: ESC, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY13, KEY34: ~, project:HE_Switch_1.75U, symbol Mechanical:Housing_Pad
- added KEY14, KEY15, KEY16, KEY17, KEY18, KEY19, KEY20, KEY21, KEY22, KEY24, KEY25, KEY27, KEY28, KEY29, KEY30, KEY31, KEY33, KEY35, KEY36, KEY37, KEY41: ~, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY2: P, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY23, KEY26, KEY32, KEY40, KEY42: ~, project:HE_Switch_1.25U, symbol Mechanical:Housing_Pad
- added KEY3: O, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY38: ~, project:HE_Switch_2.75U, symbol Mechanical:Housing_Pad
- added KEY39: ~, project:HE_Switch_2.25U, symbol Mechanical:Housing_Pad
- added KEY4: I, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY5: U, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY6: Y, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY7: T, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY8: R, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- added KEY9: E, project:HE_Switch_1.0U, symbol Mechanical:Housing_Pad
- BRC1: LCSC (none) -> C13585
- BRC2, CR_C1, CR_C2, MC3, MC4, MPC1, MPC2, MPC3: LCSC (none) -> C1525
- BRR1: LCSC (none) -> C23137
- BRR2: LCSC (none) -> C26083
- BRR3, BRR7, BRR8, LMR1: LCSC (none) -> C25744
- BRR4: LCSC (none) -> C25741
- BRR5: LCSC (none) -> C25076
- BRR6, LMR2: LCSC (none) -> C11702
- BS1: LCSC (none) -> C2886897; now in the parts list
- CR1: LCSC (none) -> C13738
- CR_R1: value 0 -> 10k; LCSC (none) -> C25744
- HEC1, HEC10, HEC11, HEC12, HEC13, HEC14, HEC15, HEC16, HEC17, HEC18, HEC19, HEC2, HEC20, HEC21, HEC22, HEC23, HEC24, HEC25, HEC26, HEC27, HEC28, HEC29, HEC3, HEC30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: value 100n -> 0.1u
- LED1, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED2, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED3, LED30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: LCSC (none) -> C5149201
- LM1: LCSC (none) -> C82045
- LMR3: LCSC (none) -> C25117
- MC1: Display value (none) -> 4.7uF; LCSC (none) -> C23733; MPN (none) -> CL05A475MP5NRNC; Mfg (none) -> Samsung
- MC2: Display value (none) -> 0.1uF; LCSC (none) -> C1525; MPN (none) -> CL05B104KO5NNNC; Mfg (none) -> Samsung
- MC5, MC6, MC7: LCSC (none) -> C307413
- MCU1: LCSC (none) -> C108516
- MFB1: LCSC (none) -> C1015
- MP1, MP2, MP3: LCSC (none) -> C98457
- PWRL1: footprint project:L_0402_1005Metric -> project:L_1210_3225Metric; LCSC (none) -> C18184936
- SD1: LCSC (none) -> C477918
- SWD1: now left out of the parts list
- USBR3: value 1k5 -> 1.5k
Connections:
- net SW29: now also MP2.6 (I3); no longer MP2.7 (I2)
- net SW38: now also MP2.7 (I2); no longer MP2.6 (I3)

Commit message: fix pinout
Parts:
- renumbered KEY39 to Key39, KEY40 to Key40, KEY41 to Key41, KEY42 to Key42
Connections:
- net SEL1: now also MCU1.40 (PB4); no longer MCU1.39 (PB3)
- net SEL2: now also MCU1.41 (PB5); no longer MCU1.40 (PB4)
- net SEL3: now also MCU1.43 (PB7); no longer MCU1.42 (PB6)
- net SEL4: now also MCU1.42 (PB6); no longer MCU1.41 (PB5)
- net SWDIO: now also MCU1.34 (PA13); no longer MCU1.38 (PA15)
- net SWO: now also MCU1.39 (PB3); no longer MCU1.20 (PB2)
- net SW_COM1: now also MCU1.38 (PA15); no longer MCU1.34 (PA13)
Changed lines of the file:
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@@
 		)
 	)
+	(global_label "SWDIO"
+		(shape input)
+		(at 177.8 86.36 0)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 186.6514 86.36 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "SW1"
 		(shape input)
@@
 	(global_label "SWO"
 		(shape input)
-		(at 144.78 86.36 180)
-		(fields_autoplaced yes)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify right)
-		)
-		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 137.8034 86.36 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify right)
-				(hide yes)
-			)
-		)
-	)
-	(global_label "SWO"
-		(shape input)
 		(at 227.965 130.175 180)
 		(fields_autoplaced yes)
@@
 		)
 	)
-	(global_label "SW_COM1"
-		(shape input)
-		(at 177.8 86.36 0)
-		(fields_autoplaced yes)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left)
-		)
-		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 189.6751 86.36 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-				(hide yes)
-			)
-		)
-	)
 	(global_label "SW11"
 		(shape input)
@@
 		)
 	)
+	(global_label "SWO"
+		(shape input)
+		(at 144.78 88.9 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 137.8034 88.9 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "SW12"
 		(shape input)
@@
 		)
 	)
-	(global_label "SEL1"
+	(global_label "SEL2"
 		(shape input)
-		(at 144.78 88.9 180)
+		(at 144.78 93.98 180)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 137.1987 88.9 0)
+			(at 137.1987 93.98 0)
 			(effects
 				(font
@@
 		)
 	)
-	(global_label "SWDIO"
-		(shape input)
-		(at 177.8 91.44 0)
-		(fields_autoplaced yes)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left)
-		)
-		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 186.6514 91.44 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify left)
-				(hide yes)
-			)
-		)
-	)
 	(global_label "SW38"
 		(shape input)
@@
 		)
 	)
-	(global_label "SEL4"
-		(shape input)
-		(at 144.78 93.98 180)
-		(fields_autoplaced yes)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify right)
-		)
-		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 137.1987 93.98 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify right)
-				(hide yes)
-			)
-		)
-	)
 	(global_label "SW24"
 		(shape input)
@@
 		)
 	)
-	(global_label "SW32"
+	(global_label "SEL1"
 		(shape input)
-		(at 312.293 323.85 0)
+		(at 144.78 91.44 180)
 		(fields_autoplaced yes)
 		(effects
@@
 				(size 1.27 1.27)
 			)
-			(justify left)
+			(justify right)
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 320.3581 323.85 0)
+			(at 137.1987 91.44 0)
 			(effects
 				(font
 					(size 1.27 1.27)
 				)
-				(justify left)
+				(justify right)
 				(hide yes)
 			)
 		)
 	)
-	(global_label "SW7"
+	(global_label "SW32"
 		(shape input)
-		(at 115.873 191.008 0)
+		(at 312.293 323.85 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 122.7286 191.008 0)
+			(at 320.3581 323.85 0)
 			(effects
 				(font
@@
 		)
 	)
-	(global_label "SEL2"
+	(global_label "SW7"
 		(shape input)
-		(at 144.78 91.44 180)
+		(at 115.873 191.008 0)
 		(fields_autoplaced yes)
 		(effects
@@
 				(size 1.27 1.27)
 			)
-			(justify right)
+			(justify left)
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 137.1987 91.44 0)
+			(at 122.7286 191.008 0)
 			(effects
 				(font
 					(size 1.27 1.27)
 				)
-				(justify right)
+				(justify left)
 				(hide yes)
 			)
@@
 		)
 	)
-	(global_label "SW16"
+	(global_label "SEL4"
 		(shape input)
-		(at 115.873 183.388 0)
+		(at 144.78 96.52 180)
 		(fields_autoplaced yes)
 		(effects
@@
 				(size 1.27 1.27)
 			)
-			(justify left)
+			(justify right)
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 123.9381 183.388 0)
+			(at 137.1987 96.52 0)
 			(effects
 				(font
 					(size 1.27 1.27)
 				)
-				(justify left)
+				(justify right)
 				(hide yes)
 			)
 		)
 	)
-	(global_label "SW35"
+	(global_label "SW16"
 		(shape input)
-		(at 49.403 360.045 0)
+		(at 115.873 183.388 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 57.4681 360.045 0)
+			(at 123.9381 183.388 0)
 			(effects
 				(font
@@
 		)
 	)
-	(global_label "SW39"
+	(global_label "SW35"
 		(shape input)
-		(at 115.873 163.068 0)
+		(at 49.403 360.045 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 123.9381 163.068 0)
+			(at 57.4681 360.045 0)
 			(effects
 				(font
@@
 		)
 	)
-	(global_label "SEL3"
+	(global_label "SW39"
 		(shape input)
-		(at 144.78 96.52 180)
+		(at 115.873 163.068 0)
 		(fields_autoplaced yes)
 		(effects
@@
 				(size 1.27 1.27)
 			)
-			(justify right)
+			(justify left)
 		)
 		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 137.1987 96.52 0)
+			(at 123.9381 163.068 0)
 			(effects
 				(font
 					(size 1.27 1.27)
 				)
-				(justify right)
+				(justify left)
 				(hide yes)
 			)
@@
 		)
 	)
+	(global_label "SEL3"
+		(shape input)
+		(at 144.78 99.06 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 137.1987 99.06 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "SW14"
 		(shape input)
@@
 		)
 	)
+	(global_label "SW_COM1"
+		(shape input)
+		(at 177.8 91.44 0)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 189.6751 91.44 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "SW9"
 		(shape input)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "KEY39"
+		(property "Reference" "Key39"
 			(at 341.63 204.7874 0)
 			(effects
@@
 			(project "feb42"
 				(path "/2e3ad76c-b131-48f6-aba9-2cacea7e39ac"
-					(reference "KEY39")
+					(reference "Key39")
 					(unit 1)
 				)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "KEY42"
-			(at 435.61 204.7874 0)
+		(property "Reference" "Key42"
+			(at 435.61 205.4224 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "~"
-			(at 435.61 207.3274 0)
+			(at 435.61 207.3275 0)
 			(effects
 				(font
@@
 			(project "feb42"
 				(path "/2e3ad76c-b131-48f6-aba9-2cacea7e39ac"
-					(reference "KEY42")
+					(reference "Key42")
 					(unit 1)
 				)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "KEY41"
-			(at 415.29 204.7874 0)
+		(property "Reference" "Key41"
+			(at 415.29 205.4224 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "~"
-			(at 415.29 207.3274 0)
+			(at 415.29 207.3275 0)
 			(effects
 				(font
@@
 			(project "feb42"
 				(path "/2e3ad76c-b131-48f6-aba9-2cacea7e39ac"
-					(reference "KEY41")
+					(reference "Key41")
 					(unit 1)
 				)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "KEY40"
-			(at 394.97 204.7874 0)
+		(property "Reference" "Key40"
+			(at 394.97 205.4224 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "~"
-			(at 394.97 207.3274 0)
+			(at 394.97 207.3275 0)
 			(effects
 				(font
@@
 			(project "feb42"
 				(path "/2e3ad76c-b131-48f6-aba9-2cacea7e39ac"
-					(reference "KEY40")
+					(reference "Key40")
 					(unit 1)
 				)

Commit message: rev2
Parts:
- removed BRC1: 10u, project:C_1206_3216Metric, symbol Device:C_Small
- removed BRC2, MC2, MC3, MC4, MC5: 100n, project:C_0402_1005Metric, symbol Device:C_Small
- removed BRD1: 1N4148WS, project:D_SOD-323, symbol Diode:1N4148WS
- removed BRQ1, BRQ2: BSS138, project:SOT-23, symbol Transistor_FET:2N7002
- removed BRR1: 330k, project:R_0603_1608Metric, symbol Device:R_Small
- removed BRR2: 1M, project:R_0402_1005Metric, symbol Device:R_Small
- removed BRR3, BRR7, BRR8, CR_R1: 10k, project:R_0402_1005Metric, symbol Device:R_Small
- removed BRR4: 100k, project:R_0402_1005Metric, symbol Device:R_Small
- removed BRR5: 100, project:R_0402_1005Metric, symbol Device:R_Small
- removed BRR6: 1k, project:R_0402_1005Metric, symbol Device:R_Small
- removed CR1: 16MHz, project:Crystal_SMD_3225-4Pin_3.2x2.5mm, symbol Device:Crystal_GND24
- removed CR_C1, CR_C2: 8p, project:C_0402_1005Metric, symbol Device:C_Small
- removed DESD1: H5VU25U, project:DFN2510, symbol Unified-Daughterboard-rescue:TPD4E05U06DQAR-acheronSymbols
- removed MC6, MC7: 1u, project:C_0402_1005Metric, symbol Device:C_Small
- removed MCU1: STM32F303CBT6, project:LQFP-48_7x7mm_P0.5mm, symbol MCU_ST_STM32F3:STM32F303CBTx
- removed MFB1: 120R @ 100MHz, project:L_0805_2012Metric, symbol Device:FerriteBead_Small
- removed SWD1: Conn_02x03_Odd_Even, project:DBG_header, symbol Connector_Generic:Conn_02x03_Odd_Even
- removed USBR3: 1.5k, Resistor_SMD:R_0402_1005Metric, symbol Device:R_Small
- added BRC3: 10u, project:C_1206_3216Metric, symbol Device:C_Small
- added BRD2: 1N4148WS, project:D_SOD-323, symbol Diode:1N4148WS
- added BRR9: 1M, project:R_0402_1005Metric, symbol Device:R_Small
- added CR2: 16MHz, project:Crystal_SMD_3225-4Pin_3.2x2.5mm, symbol Device:Crystal_GND24
- added CR_C3, CR_C4: 10p, project:C_0402_1005Metric, symbol Device:C_Small
- added D1: PW_LED 0603, LED_SMD:LED_0603_1608Metric, symbol Device:LED
- added J1: Conn_01x04_Socket, project:DBG_header, symbol Connector:Conn_01x05_Socket
- added MC10, MC11, MC8, MC9: 100n, project:C_0402_1005Metric, symbol Device:C_Small
- added MC12: 10u, project:C_0402_1005Metric, symbol Device:C_Small
- added MC13: 10n, project:C_0402_1005Metric, symbol Device:C_Small
- added MC14, MC15: 1u, project:C_0402_1005Metric, symbol Device:C_Small
- added MFB2: 120R @ 100MHz, project:L_0805_2012Metric, symbol Device:FerriteBead_Small
- added Q1, Q2: 2N7002, Package_TO_SOT_SMD:SOT-23, symbol Transistor_FET:2N7002
- added R2: 5.1k, project:R_0402_1005Metric, symbol Device:R
- added R4, R5, R8: 10k, project:R_0402_1005Metric, symbol Device:R
- added R6: 100, project:R_0402_1005Metric, symbol Device:R
- added R7: 1k, project:R_0402_1005Metric, symbol Device:R
- added R9: 100k, project:R_0402_1005Metric, symbol Device:R
- added U1: STM32F411CEU6, Package_DFN_QFN:QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm, symbol MCU_ST_STM32F4:STM32F411CEUx
- BS1: LCSC C2886897 -> (none)
- LM1: footprint project:SOT-23 -> Package_TO_SOT_SMD:SOT-23; LCSC C82045 -> (none)
- LMR1: footprint project:R_0402_1005Metric -> Resistor_SMD:R_0402_1005Metric; LCSC C25744 -> (none)
- LMR2: footprint project:R_0402_1005Metric -> Resistor_SMD:R_0402_1005Metric; LCSC C11702 -> (none)
- LMR3: footprint project:R_0402_1005Metric -> Resistor_SMD:R_0402_1005Metric; LCSC C25117 -> (none)
- MC1: value 4u7 -> 100n; Display value 4.7uF -> 0.1uF; LCSC C23733 -> C1525; MPN CL05A475MP5NRNC -> CL05B104KO5NNNC
- USBR1: LCSC Part (none) -> C25905
- USBR2: LCSC Part C25905 -> (none)
Connections:
- net +3V3: now also BS1.2, D1.2 (A), J1.4 (Pin_4), MC10.1, MC11.1, MC12.1, MC15.1, MC8.1, MC9.1, MFB2.1, U1.1 (VBAT), U1.24 (VDD)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; no longer MC1.1
- net BOOT: now also BRC3.1, BRD2.1 (K), BRR9.1, R5.2, U1.44 (BOOT0)
- net GND: now also USBR1.2, USBR2.2, BRC3.2, BRR9.2, CR2.2, CR2.4, CR_C3.1, CR_C4.1, J1.2 (Pin_2), MC10.2, MC11.2, MC12.2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; no longer BS1.1, LED14.1 (VSS), LED15.1 (VSS), LED16.1 (VSS), USBR1.1, USBR2.1
- net LED_IN: now also LMR3.2; no longer LMR3.1
- net RGB_DATA: now also U1.17 (PA7)
- net SEL1: now also U1.40 (PB4)
- net SEL2: now also U1.41 (PB5)
- net SEL3: now also U1.43 (PB7)
- net SEL4: now also U1.42 (PB6)
- net SWCLK: now also J1.3 (Pin_3), U1.37 (PA14)
- net SWDIO: now also J1.1 (Pin_1), U1.34 (PA13)
- net SWO: now also J1.5 (Pin_5), U1.39 (PB3)
- net SW_COM1: now also U1.10 (PA0)
- net SW_COM2: now also U1.11 (PA1)
- net SW_COM3: now also U1.12 (PA2)
- net USB_D+: now also U1.33 (PA12)
- net USB_D-: now also U1.32 (PA11)
- net at LM1.3 (D), LMR2.1: now also LMR3.1; no longer LMR3.2
- net at USB1.A5 (CC1): now also USBR2.1; no longer USBR2.2
- net at USB1.B5 (CC2): now also USBR1.1; no longer USBR1.2
- new net: BRD2.2 (A), BS1.1, R7.1
- new net: Q2.1 (G), R7.2, R8.2
- new net: Q2.3 (D), R4.1, R6.1
- new net: Q1.1 (G), R4.2, R9.2
- new net: Q1.3 (D), R5.1
- new net: D1.1 (K), R2.2
- new net +3.3VA: MC13.1, MC14.1, MFB2.2, U1.9 (VDDA)
- new net CR_IN: CR2.1, CR_C4.2, U1.5 (PH0)
- new net CR_OUT: CR2.3, CR_C3.2, U1.6 (PH1)
- new net NRST: MC1.1, R6.2, U1.7 (NRST)
- no-connect marks 2 -> 24
Other:
- note added: "Key Footprints"
- note removed: "9pF"
- note removed: "Analog operating voltage (VDDA) supply"
- note removed: "Boot/Reset"
- note removed: "Crystal"
- note removed: "Debug"
- note removed: "Power"
- note removed: "Standard operating voltage (VDD) supply"
